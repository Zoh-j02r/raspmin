PACKAGECONFIG:append = " vpx" 
PACKAGECONFIG:remove = " mpg123 pulseaudio cairo flac gdk-pixbuf" 
