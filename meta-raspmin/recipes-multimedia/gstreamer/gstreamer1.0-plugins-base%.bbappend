PACKAGECONFIG:remove = " pango" 
